# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: TM4C123GH6PZ Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ProjectExecuable
  c flags: Optim=1
  c define: PART_TM4C123GH6PZ
  c misc: --C99
  c include: C:\Ti\TivaWare_C_Series-2.1.2.111;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../Startup/: startup_TM4C123.s
  group User
    ../User/: main.c udf_delay.c udf_uart.c
  group Library
    C:/Ti/TivaWare_C_Series-2.1.2.111/driverlib/rvmdk/: driverlib.lib
  group Instruction
    ../Instruction/: readme.txt
